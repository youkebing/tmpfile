# Keil uVision project rtugw.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: rtugw +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group src
    ./src/: Main.c uart1.c led.c crc16.c uart2.c timer.c uart3.c
